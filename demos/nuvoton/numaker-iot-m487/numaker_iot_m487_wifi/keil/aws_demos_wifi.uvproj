# Keil uVision project aws_demos_wifi.uvproj, settings and files
target aws_demos (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: aws_demos +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx NDEBUG __little_endian__=1
  c misc: --diag_suppress=550,177,C4017,111,2770,223
  c include: ..\..\..\..\..\lib\include;..\..\..\..\..\lib\include\private;..\..\..\..\..\lib\third_party\mcu_vendor\nuvoton\M480\Device\Nuvoton\M480\Include;..\..\..\..\..\lib\third_party\mcu_vendor\nuvoton\M480\StdDriver\inc;..\..\..\..\..\demos\common\include;..\..\..\..\..\lib\FreeRTOS\portable\RVDS\ARM_CM4F;..\;..\..\..\..\..\lib\FreeRTOS-Plus-TCP\include;..\..\..\..\..\lib\FreeRTOS-Plus-TCP\source\protocols\include;..\..\..\..\..\lib\FreeRTOS-Plus-TCP\source\portable\NetworkInterface\M487;..\..\..\..\..\lib\FreeRTOS-Plus-TCP\source\portable\Compiler\Keil;..\..\..\..\..\lib\third_party\mcu_vendor\nuvoton\M480\CMSIS\Include;..\..\..\..\..\lib\third_party\mcu_vendor\nuvoton\M480\middleware\wifi_esp8266;..\common\config_files;..\..\..\..\..\lib\third_party\mbedtls\include;..\..\..\..\common\include;..\..\..\..\..\lib\third_party\jsmn;..\..\..\..\..\lib\third_party\pkcs11;..\..\..\..\..\lib\third_party\tinycbor
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group CMSIS
    ../../../../../lib/third_party/mcu_vendor/nuvoton/M480/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../../../../../lib/third_party/mcu_vendor/nuvoton/M480/Device/Nuvoton/M480/Source/: system_M480.c
  group User
    ../common/application_code/nuvoton_code/: entropy_hardware_poll.c
    ../common/application_code/: main.c
  group FreeRTOS
    ../../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../lib/FreeRTOS/portable/MemMang/: heap_4.c
  group NVT-Library
    ../../../../../lib/third_party/mcu_vendor/nuvoton/M480/StdDriver/src/: retarget.c clk.c crypto.c fmc.c gpio.c sys.c spim.c uart.c
  group demos
    ../../../../common/demo_runner/: aws_demo_runner.c
    ../../../../common/tcp/: aws_tcp_echo_client_single_task.c aws_tcp_echo_client_separate_tasks.c
    ../../../../common/mqtt/: aws_hello_world.c aws_subscribe_publish_loop.c
    ../../../../common/shadow/: aws_shadow_lightbulb_on_off.c
    ../../../../common/logging/: aws_logging_task_dynamic_buffers.c
    ../../../../common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
    ../../../../common/ota/: aws_ota_update_demo.c
  group wifi
    ../../../../../lib/wifi/portable/nuvoton/numaker-iot-m487/: aws_wifi.c
    ../../../../../lib/third_party/mcu_vendor/nuvoton/M480/middleware/wifi_esp8266/: esp8266_wifi.c
  group lib-bufferpool
    ../../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib-crypto
    ../../../../../lib/crypto/: aws_crypto.c
  group lib-mqtt
    ../../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib-pkcs11
    ../../../../../lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../../lib/pkcs11/portable/nuvoton/numaker-iot-m487/: aws_pkcs11_pal.c
  group lib-secure_sockets
    ../../../../../lib/secure_sockets/portable/nuvoton/numaker-iot-m487/: aws_secure_sockets.c
  group lib-shadow
    ../../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib-tls
    ../../../../../lib/tls/: aws_tls.c
  group lib-utils
    ../../../../../lib/utils/: aws_system_init.c
  group 3rd-jsmn
    ../../../../../lib/third_party/jsmn/: jsmn.c
  group 3rd-mbedtls
    ../../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c platform_util.c
  group lib-ota
    ../../../../../lib/ota/: aws_ota_agent.c aws_ota_cbor.c
    ../../../../../lib/ota/portable/nuvoton/numaker-iot-m487/: aws_ota_pal.c aws_ota_pal_spim.c
  group 3rd-tinycbor
    ../../../../../lib/third_party/tinycbor/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c
